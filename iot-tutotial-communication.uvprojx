# Keil uVision project iot-tutotial-communication.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC4337:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.6.0
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: iot-tutotial-communication
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group app
    ./: main.c Modem_SIM900.c CommunicationThread.c mqtt_keilds_transport.c
  group mqtt
    ./mqtt/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Security:mbed TLS 2.1.2, Network:CORE 7.0.0, Network:Interface:PPP 7.0.0, Network:Service:DNS Client 7.0.0, Network:Socket:BSD 7.0.0, Network:Socket:TCP 7.0.0, Network:Socket:UDP 7.0.0, CMSIS Driver:USART 2.8, Compiler:I/O:STDOUT 1.0.0, Device:GPDMA 1.4, Device:SCU 1.1, Device:Startup 1.0.0
